# Keil uVision project caliper.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: caliper
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c soft_spi.c gpio.c clk.c timer.c usart.c
  group headers
    ./: main.h soft_spi.h gpio.h clk.h timer.h usart.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.5, Drivers:DMA 1.5, Drivers:EEPROM 1.5, Drivers:IWDG 1.5, Drivers:PORT 1.5, Drivers:POWER 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5, Drivers:WWDG 1.5
